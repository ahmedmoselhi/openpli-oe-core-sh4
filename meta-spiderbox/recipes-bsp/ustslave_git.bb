DESCRIPTION = "A tool for uploading the firmware to the slave DSPs"

require sh4-apps.inc

RDEPEND += "stslave-fw"
