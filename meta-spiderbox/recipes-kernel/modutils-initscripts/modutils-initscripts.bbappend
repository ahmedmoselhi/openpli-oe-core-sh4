SRC_URI_append_hl101 += "\
    file://hl101_modutils.patch \
"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"