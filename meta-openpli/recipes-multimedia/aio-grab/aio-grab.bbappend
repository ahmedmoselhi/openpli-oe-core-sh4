SRC_URI_sh4 = "${GITHUB_URI}/oe-alliance/${BPN}.git"
