SRC_URI_append_sh4 += " \
		file://rt8723bs_sh4.patch \
"
