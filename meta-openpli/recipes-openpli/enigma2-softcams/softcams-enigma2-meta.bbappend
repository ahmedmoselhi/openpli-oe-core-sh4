DEPENDS_remove_sh4 += "\
	enigma2-plugin-softcams-cccam \
"
